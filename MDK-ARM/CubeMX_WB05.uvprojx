# Keil uVision project CubeMX_WB05.uvprojx, settings and files
target CubeMX_WB05 (6070000::V6.7::.\ARMCLANG)
  device: STM32WB05KZVx STMicroelectronics
  pack: Keil.STM32WB0x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00006000) IRAM2(0x20000018,0x00002FE8) IROM(0x10040000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: CubeMX_WB05
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WB05
  c misc: -fshort-enums
  c include: ../Core/Inc;../Drivers/STM32WB0x-nucleo;../Drivers/STM32WB0x_HAL_Driver/Inc;../Drivers/STM32WB0x_HAL_Driver/Inc/Legacy;../System/Config/Debug_GPIO;../Utilites;../BLE/Interfaces;../BLE/Modules;../BLE/Modules/NVMDB/Inc;../BLE/Modules/PKAMGR/Inc;../BLE/Modules/Profiles/Inc;../BLE/Modules/RADIO_utils/Inc;../BLE/Modules/RTDebug;../BLE/Startup;../STM32_BLE/;../STM32_BLE/App;../STM32_BLE/cryptolib/Inc;../STM32_BLE/evt_handler/inc;../STM32_BLE/Stack;../STM32_BLE/Target
  memory RVCT4: ROM 0x10040000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: stm32wb05_flash.sct
  link misc: --diag_suppress=L6312W
--diag_suppress=L6314W
--diag_suppress=L6318W
--diag_suppress=L6329W
  group Application/MDK-ARM
    ./: startup_stm32wb05.s
  group Application/User/Core
    ../Core/Src/: app_entry.c conversion.c main.c stm32wb0x_it.c stm32wb0x_hal_msp.c system.c
  group BLE/Interfaces
    ../BLE/Interfaces/: cryptolib_hw_aes.c hw_aes.c hw_pka.c hw_rng.c stm32_lpm_if.c
  group BLE/Modules
    ../BLE/Modules/: miscutil.c osal.c stm_list.c blue_unit_conversion.s osal_memcpy.s
  group BLE/Modules/NVMDB
    ../BLE/Modules/NVMDB/Src/: nvm_db.c nvm_db_conf.c
  group BLE/Modules/PKAMGR
    ../BLE/Modules/PKAMGR/Src/: pka_manager.c
  group BLE/Modules/Profiles
    ../BLE/Modules/Profiles/Src/: gap_profile.c gatt_profile.c
  group BLE/Modules/RADIO_utils
    ../BLE/Modules/RADIO_utils/Src/: RADIO_utils.c
  group BLE/Modules/RTDebug
    ../BLE/Modules/RTDebug/: RTDebug.c
  group BLE/Startup
    ../BLE/Startup/: cpu_context_switch.s device_context_switch.c
  group Drivers/STM32WB0x-nucleo
    ../Drivers/STM32WB0x-nucleo/: stm32wb0x_nucleo.c
  group Drivers/STM32WB0x_HAL_Driver
    ../Drivers/STM32WB0x_HAL_Driver/Src/: stm32wb0x_hal_adc.c stm32wb0x_hal_rcc.c stm32wb0x_hal_rcc_ex.c stm32wb0x_hal_flash.c stm32wb0x_hal_flash_ex.c stm32wb0x_hal_gpio.c stm32wb0x_hal_dma.c stm32wb0x_hal_pka.c stm32wb0x_hal_pwr.c stm32wb0x_hal_pwr_ex.c stm32wb0x_hal_cortex.c stm32wb0x_hal.c stm32wb0x_hal_radio.c stm32wb0x_hal_radio_timer.c stm32wb0x_hal_rtc.c stm32wb0x_hal_rtc_ex.c stm32wb0x_hal_tim.c stm32wb0x_hal_tim_ex.c stm32wb0x_hal_uart.c stm32wb0x_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wb0x.c
  group STM32_BLE/App
    ../STM32_BLE/App/: app_ble.c dis.c dis_app.c hts.c hts_app.c
  group STM32_BLE/cryptolib
    ../STM32_BLE/cryptolib/: libcrypto.a
  group STM32_BLE/evt_handler
    ../STM32_BLE/evt_handler/src/: ble_evt.c
  group STM32_BLE/stack
    ../STM32_BLE/Stack/: ble_stack_user_cfg.c stm32wb0x_ble_stack.a
  group STM32_BLE/Target
    ../STM32_BLE/Target/: blenvm.c bleplat.c bleplat_cntr.c
  group System
    ../System/Config/Debug_GPIO/: app_debug.c
    ../System/Interfaces/: usart_if.c
  group Utilites
    ../Utilites/: stm32_adv_trace.c stm32_lpm.c stm32_mem.c stm32_seq.c
software components: CMSIS:CORE 5.6.0
